# Repository kumots/irog2k-pcb-demo

File README.md:

# Irog - Noun in Tagalog, meaning Dear One, or Beloved.

I have no idea how this is related to the project, but it just sounds cool.

Anyways, this is just a simple 2-key keypad that you can order and assemble yourself to practice your skills in soldering and electronic work overall. You can download the ZIP file containing all the gerber files and upload it to JLCPCB or any other platform that offers PCB printing services. You can also refer to the attatched schematics and PCB KiCad files for further details.

This keypad is powered with a Mini-USB slot for simplicity, and also does not come with hotswap sockets, unfortunately(I don't know how to add them lmao).

Parts you will need to order:

**x3 0.1uF Ceramic Capacitator, 0805 Package**

**x1 10uF Ceramic Capacitator, 0805 Package**

**x1 1uF Ceramic Capacitator, 0805 Package**

**x2 22pF Ceramic Capacitator, 0805 Package**

**x2 Generic Diode, SOD-123 Package**

**x1 500mA Hold 1A Trip Polyfuse, 1206 Package**

**x2 10k Resistor, 0805 Package**

**x2 22 Resistor, 0805 Package**

**x1 Low Profile Tactile Switch, 5.2x5.2mm Package**

**x1 ATMEGA32U4 Microcontroller, 44TQFP 10x10mm Package**

**x1 Molex Mini-B USB C Receptacle, Molex-0548190589 Package**

**x1 16MHz Crystal, 3.2x2.5mm 4 pad Package**

## KiCad design irog2k-pcb-demo.kicad_pcb

Parts:
C1, C2, C5: 0.1uF; C_0805_2012Metric
C3, C4: 22pF; C_0805_2012Metric
C6: 1uF; C_0805_2012Metric
C7: 10uF; C_0805_2012Metric
D1, D2: SOD-123; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
MX1, MX2: MX-NoLED; MX-1U
R1, R2: 22; R_0805_2012Metric
R3, R4: 10k; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
USB1: Molex-0548190589
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, C5.1, C7.1, F1.1, R3.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL0: MX1.1 (COL), U1.28 (PB4)
COL1: MX2.1 (COL), U1.29 (PB5)
D+: R2.2, USB1.3 (D+)
D-: R1.2, USB1.4 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R4.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), USB1.1 (GND), Y1.2, Y1.4
unnamed: C3.1, U1.17 (XTAL1), Y1.1
unnamed: C4.1, U1.16 (XTAL2), Y1.3
unnamed: C6.1, U1.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: R1.1, U1.3 (D-)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.2, SW1.2, U1.13 (~RESET)
unnamed: R4.2, U1.33 (~HWB~/PE2)
ROW0: D1.1 (K), D2.1 (K)
VCC: F1.2, USB1.5 (VBUS)

Board: 2 copper layers, 42.9 x 61.1 mm, 20 parts (18 on the bottom side), 17 nets.

## Commit log

2024-07-22 basic files
2024-07-22 submodules add
2024-07-22 libraries implemented
2024-07-22 schema
2024-07-22 pcb(not done)
2024-07-23 pcb (finished)
2024-07-23 gerber files added
2024-07-23 zip file for gerbers made
2024-07-24 readme created
2024-07-24 readme updated
